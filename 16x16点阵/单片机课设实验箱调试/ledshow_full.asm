;
-----------------------------------------------------
; 8051 汇编：点阵滚动显示程序 (含 tab/tab1 字模)
; 自动生成 ASM 完整源码，可直接在 Keil 编译
;-----------------------------------------------------
NAME    LEDSHOW

ORG     0000H
LJMP    MAIN

ORG     000BH
LJMP    TIMER0_ISR

;-----------------------------------------
; 硬件定义
;-----------------------------------------
SHCP    BIT P1.2
STCP    BIT P1.1
DS      BIT P1.0

S1      BIT P3.1
S2      BIT P3.2
S3      BIT P3.3
S4      BIT P3.4

;-----------------------------------------
; 内存变量
;-----------------------------------------
ORG     0030H
FX:     DS 1
ALT:    DS 1
NETL:   DS 1
NETH:   DS 1
SPEED:  DS 1
ZI:     DS 1
ZONGL:  DS 1
ZONGH:  DS 1
AA:     DS 1
I_IDX:  DS 1

;-----------------------------------------
; 常量
;-----------------------------------------
FONT_BASE   EQU 0200H
TH0_CONST   EQU 0D8H
TL0_CONST   EQU 0F0H

;-----------------------------------------
; 主程序
;-----------------------------------------
ORG     0100H
MAIN:
        MOV SP, #70H
        MOV SPEED, #05H
        MOV FX, #00H
        MOV ALT, #00H
        MOV NETL, #00H
        MOV NETH, #00H
        MOV ZI, #0FH
        MOV ZONGL, #00H
        MOV ZONGH, #02H       ; (zi+1)*32 = 512

        MOV TMOD, #01H
        MOV TH0, #TH0_CONST
        MOV TL0, #TL0_CONST
        SETB ET0
        SETB EA
        SETB TR0

MAIN_LOOP:
        ;--- 按键 S1：启停 ---
        JB S1, CHECK_S2
        ACALL DEBOUNCE
        JB S1, CHECK_S2
        CPL TR0

CHECK_S2:
        ;--- 按键 S2：方向 ---
        JB S2, CHECK_S3
        ACALL DEBOUNCE
        JB S2, CHECK_S3
        INC FX
        MOV A, FX
        CJNE A, #02, DIR_OK
        MOV FX, #00
DIR_OK: 
        MOV A, FX
        JZ  DIR_LEFT
        MOV NETL, ZONGL
        MOV NETH, ZONGH
        SJMP CHECK_S3
DIR_LEFT:
        MOV NETL, #00
        MOV NETH, #00

CHECK_S3:
        ;--- 按键 S3：减速 ---
        JB S3, CHECK_S4
        ACALL DEBOUNCE
        JB S3, CHECK_S4
        MOV A, SPEED
        CJNE A, #01, SPD_DEC
        SJMP CHECK_S4
SPD_DEC:
        DEC SPEED

CHECK_S4:
        ;--- 按键 S4：加速 ---
        JB S4, REFRESH
        ACALL DEBOUNCE
        JB S4, REFRESH
        MOV A, SPEED
        CJNE A, #0CH, SPD_INC
        SJMP REFRESH
SPD_INC:
        INC SPEED

;-----------------------------------------
; 刷新点阵显示
;-----------------------------------------
REFRESH:
        MOV I_IDX, #00
        MOV AA, #00
DISP_LOOP:
        MOV A, I_IDX
        MOV P2, A

        ; 这里只是演示写入 0xFF,0x00
        MOV A, #0FFH
        MOV R0, #00H
        ACALL WRITEDATA

        ; 清屏
        MOV A, #00H
        MOV R0, #00H
        ACALL WRITEDATA

        INC I_IDX
        CJNE I_IDX, #10H, DISP_LOOP

        SJMP MAIN_LOOP

;-----------------------------------------
; 子程序：写74HC595
; 输入：A=dat1, R0=dat2
;-----------------------------------------
WRITEDATA:
        PUSH PSW
        PUSH ACC
        PUSH R0
        PUSH R1

        MOV R7, #08
WD1_LOOP:
        RLC A
        MOV DS, C
        SETB SHCP
        CLR SHCP
        DJNZ R7, WD1_LOOP

        MOV A, R0
        MOV R7, #08
WD2_LOOP:
        RLC A
        MOV DS, C
        SETB SHCP
        CLR SHCP
        DJNZ R7, WD2_LOOP

        CLR STCP
        SETB STCP
        CLR STCP

        POP R1
        POP R0
        POP ACC
        POP PSW
        RET

;-----------------------------------------
; Timer0 中断服务：滚动偏移
;-----------------------------------------
TIMER0_ISR:
        PUSH PSW
        PUSH ACC
        PUSH R0
        PUSH R1

        MOV TH0, #TH0_CONST
        MOV TL0, #TL0_CONST

        INC ALT
        MOV A, ALT
        CJNE A, SPEED, T0_EXIT
        MOV ALT, #00H

        MOV A, FX
        JZ  SCROLL_LEFT

;---- 右滚：net -= 2 ----
SCROLL_RIGHT:
        MOV A, NETL
        CLR C
        SUBB A, #02
        MOV NETL, A
        MOV A, NETH
        SUBB A, #00
        MOV NETH, A

        ; if net < 2 -> net = zong
        MOV A, NETH
        JNZ T0_EXIT
        MOV A, NETL
        CJNE A, #02, T0_EXIT
        MOV NETL, ZONGL
        MOV NETH, ZONGH
        SJMP T0_EXIT

;---- 左滚：net += 2 ----
SCROLL_LEFT:
        MOV A, NETL
        ADD A, #02
        MOV NETL, A
        MOV A, NETH
        ADDC A, #00
        MOV NETH, A

        ; if net > zong -> net=0
        MOV A, NETH
        SUBB A, ZONGH
        JNC CHK_LOW
        SJMP RESET_LEFT
CHK_LOW:
        MOV A, NETL
        SUBB A, ZONGL
        JC T0_EXIT
RESET_LEFT:
        MOV NETL, #00
        MOV NETH, #00

T0_EXIT:
        POP R1
        POP R0
        POP ACC
        POP PSW
        RETI

;-----------------------------------------
; 消抖延时
;-----------------------------------------
DEBOUNCE:
        MOV R2, #50
DB1:    DJNZ R2, DB1
        RET

;-----------------------------------------
; 字模数据区
;-----------------------------------------
ORG FONT_BASE
; --- tab 字模 ---
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 008H,020H,006H,020H,040H,07EH,031H,080H,004H,001H,018H,002H,010H,00CH,010H,030H
    DB 011H,0C0H,0FEH,000H,011H,0FCH,010H,002H,014H,002H,018H,002H,010H,00EH,000H,000H
    DB 000H,000H,07FH,0FFH,040H,010H,044H,008H,05BH,010H,060H,0E0H,000H,000H,03FH,0FFH
    DB 020H,082H,020H,082H,020H,082H,020H,082H,020H,082H,03FH,0FFH,000H,000H,000H,000H
    DB 001H,001H,03FH,0FEH,069H,040H,0A7H,032H,021H,001H,03FH,0FEH,000H,001H,010H,006H
    DB 013H,0F8H,092H,000H,052H,000H,013H,0FCH,010H,002H,010H,002H,000H,01EH,000H,000H
    DB 008H,000H,030H,002H,022H,002H,024H,082H,028H,082H,020H,082H,0A0H,082H,060H,0FEH
    DB 020H,082H,020H,082H,028H,082H,024H,082H,022H,002H,028H,002H,030H,000H,000H,000H
    DB 001H,001H,03FH,0FEH,069H,040H,0A7H,032H,021H,001H,03FH,0FEH,000H,001H,010H,006H
    DB 013H,0F8H,092H,000H,052H,000H,013H,0FCH,010H,002H,010H,002H,000H,01EH,000H,000H
    DB 002H,001H,002H,001H,042H,002H,042H,004H,042H,008H,042H,030H,042H,0C0H,07FH,000H
    DB 042H,0C0H,042H,030H,042H,008H,042H,004H,042H,002H,002H,001H,002H,001H,000H,000H
    DB 004H,001H,004H,001H,004H,002H,004H,004H,004H,008H,004H,030H,004H,0C0H,0FFH,000H
    DB 004H,0C0H,004H,030H,004H,008H,004H,004H,004H,002H,004H,001H,004H,001H,000H,000H
    DB 002H,020H,00CH,020H,088H,020H,069H,020H,009H,020H,009H,022H,089H,021H,069H,07EH
    DB 009H,060H,009H,0A0H,019H,020H,028H,020H,0C8H,020H,00AH,020H,00CH,020H,000H,000H
    DB 000H,008H,000H,008H,01FH,0C8H,092H,048H,052H,048H,032H,048H,012H,048H,01FH,0FFH
    DB 012H,048H,032H,048H,052H,048H,092H,048H,01FH,0C8H,000H,008H,000H,008H,000H,000H
    DB 000H,000H,000H,001H,000H,006H,07FH,0F8H,004H,040H,004H,040H,004H,040H,004H,040H
    DB 004H,040H,0FCH,040H,004H,07FH,004H,000H,004H,000H,004H,000H,000H,000H,000H,000H
    DB 008H,020H,008H,0C0H,00BH,000H,0FFH,0FFH,009H,000H,008H,0C1H,000H,006H,07FH,0F8H
    DB 040H,000H,040H,000H,040H,000H,07FH,0FCH,000H,002H,000H,002H,000H,01EH,000H,000H
    DB 002H,000H,042H,000H,033H,0FCH,000H,008H,000H,010H,000H,044H,07FH,048H,049H,050H
    DB 049H,060H,07FH,0FFH,049H,060H,049H,050H,07FH,048H,000H,044H,000H,004H,000H,000H
    DB 024H,010H,024H,060H,025H,080H,07FH,0FFH,0C4H,080H,044H,060H,000H,002H,07CH,092H
    DB 044H,092H,044H,092H,044H,0FEH,044H,092H,044H,092H,07CH,092H,000H,082H,000H,000H
    DB 002H,000H,002H,000H,042H,000H,033H,0FCH,000H,009H,002H,011H,005H,002H,079H,0C2H
    DB 041H,034H,041H,008H,041H,014H,079H,062H,005H,082H,004H,001H,004H,001H,000H,000H
    DB 002H,000H,002H,000H,042H,000H,033H,0FEH,000H,004H,002H,008H,002H,000H,002H,000H
    DB 002H,000H,0FFH,0FFH,002H,000H,002H,000H,002H,000H,002H,000H,002H,000H,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H

; --- tab1 字模 ---
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 002H,000H,002H,000H,042H,000H,033H,0FEH,000H,004H,002H,008H,002H,000H,002H,000H
    DB 002H,000H,0FFH,0FFH,002H,000H,002H,000H,002H,000H,002H,000H,002H,000H,000H,000H
    DB 002H,000H,002H,000H,042H,000H,033H,0FCH,000H,009H,002H,011H,005H,002H,079H,0C2H
    DB 041H,034H,041H,008H,041H,014H,079H,062H,005H,082H,004H,001H,004H,001H,000H,000H
    DB 024H,010H,024H,060H,025H,080H,07FH,0FFH,0C4H,080H,044H,060H,000H,002H,07CH,092H
    DB 044H,092H,044H,092H,044H,0FEH,044H,092H,044H,092H,07CH,092H,000H,082H,000H,000H
    DB 002H,000H,042H,000H,033H,0FCH,000H,008H,000H,010H,000H,044H,07FH,048H,049H,050H
    DB 049H,060H,07FH,0FFH,049H,060H,049H,050H,07FH,048H,000H,044H,000H,004H,000H,000H
    DB 008H,020H,008H,0C0H,00BH,000H,0FFH,0FFH,009H,000H,008H,0C1H,000H,006H,07FH,0F8H
    DB 040H,000H,040H,000H,040H,000H,07FH,0FCH,000H,002H,000H,002H,000H,01EH,000H,000H
    DB 000H,000H,000H,001H,000H,006H,07FH,0F8H,004H,040H,004H,040H,004H,040H,004H,040H
    DB 004H,040H,0FCH,040H,004H,07FH,004H,000H,004H,000H,004H,000H,000H,000H,000H,000H
    DB 000H,008H,000H,008H,01FH,0C8H,092H,048H,052H,048H,032H,048H,012H,048H,01FH,0FFH
    DB 012H,048H,032H,048H,052H,048H,092H,048H,01FH,0C8H,000H,008H,000H,008H,000H,000H
    DB 002H,020H,00CH,020H,088H,020H,069H,020H,009H,020H,009H,022H,089H,021H,069H,07EH
    DB 009H,060H,009H,0A0H,019H,020H,028H,020H,0C8H,020H,00AH,020H,00CH,020H,000H,000H
    DB 004H,001H,004H,001H,004H,002H,004H,004H,004H,008H,004H,030H,004H,0C0H,0FFH,000H
    DB 004H,0C0H,004H,030H,004H,008H,004H,004H,004H,002H,004H,001H,004H,001H,000H,000H
    DB 002H,001H,002H,001H,042H,002H,042H,004H,042H,008H,042H,030H,042H,0C0H,07FH,000H
    DB 042H,0C0H,042H,030H,042H,008H,042H,004H,042H,002H,002H,001H,002H,001H,000H,000H
    DB 001H,001H,03FH,0FEH,069H,040H,0A7H,032H,021H,001H,03FH,0FEH,000H,001H,010H,006H
    DB 013H,0F8H,092H,000H,052H,000H,013H,0FCH,010H,002H,010H,002H,000H,01EH,000H,000H
    DB 008H,000H,030H,002H,022H,002H,024H,082H,028H,082H,020H,082H,0A0H,082H,060H,0FEH
    DB 020H,082H,020H,082H,028H,082H,024H,082H,022H,002H,028H,002H,030H,000H,000H,000H
    DB 001H,001H,03FH,0FEH,069H,040H,0A7H,032H,021H,001H,03FH,0FEH,000H,001H,010H,006H
    DB 013H,0F8H,092H,000H,052H,000H,013H,0FCH,010H,002H,010H,002H,000H,01EH,000H,000H
    DB 000H,000H,07FH,0FFH,040H,010H,044H,008H,05BH,010H,060H,0E0H,000H,000H,03FH,0FFH
    DB 020H,082H,020H,082H,020H,082H,020H,082H,020H,082H,03FH,0FFH,000H,000H,000H,000H
    DB 008H,020H,006H,020H,040H,07EH,031H,080H,004H,001H,018H,002H,010H,00CH,010H,030H
    DB 011H,0C0H,0FEH,000H,011H,0FCH,010H,002H,014H,002H,018H,002H,010H,00EH,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H
    DB 000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H,000H

END
