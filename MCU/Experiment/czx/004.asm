	ORG 0
	AJMP START
	
	ORG	000BH
	AJMP	TIMER0_ISR
	
	ORG 50H
	
	START:
		MOV P1,	#00H
		MOV	R0,	#0
	
		MOV	TMOD,	#61H
		MOV	TH0,	#3CH
		MOV	TL0,	#0B0H
		MOV	TH1,	#00H
		MOV	TL1,	#00H
		MOV R1,#10
		
		SETB	EA
		SETB	ET0
		SETB	TR0
		SETB	TR1
	
	MAIN_LOOP:
		
		MOV	A,	TL1
		MOV	C,	0
		MOV	ACC.7,	C

		MOV	P1,	A
		SJMP	MAIN_LOOP	
	
	TIMER0_ISR:
		PUSH	ACC
		PUSH	PSW
	
		INC	R0
		CJNE	R0,	#4,	TIMER0_RET
		
		T_L1:
			CPL	0
			MOV	R0,	#0
		
		TIMER0_RET:

			MOV	TH0,	#3CH
			MOV	TL0,	#0B0H
DJNZ R1,LOP1
CPL P3.0
MOV R1,#10	
LOP1:   	POP	PSW
			POP	ACC
			RETI
	
	END

