	ORG	0
	LJMP	MAIN
	ORG	50H
	MAIN:
		MOV	SP,	#60H
		ACALL	INIT_UART
lop1:	ACALL	RECEIVE_DATA
		ACALL	SEND_ACK
		SJMP	lop1

	INIT_UART:
		MOV	TMOD,	#20H
		MOV	TH1,	#0F4H
		MOV	TL1,	#0F4H
		SETB	TR1

		MOV	SCON,	#50H
		CLR	RI
		CLR	TI
		RET

	RECEIVE_DATA:
		MOV	R0,	#30H
		MOV	R7,	#08H

	RECV_LOOP:
		JNB	RI,	$
		CLR	RI
		MOV	A,	SBUF
		MOV	@R0,	A
		INC	R0
		DJNZ	R7,	RECV_LOOP
		RET
	
	SEND_ACK:
		MOV	A,	#55H
		MOV	SBUF,	A
		ACALL	SEND_BYTE
		
		MOV	A,	#0AAH
		MOV	SBUF,	A
		ACALL	SEND_BYTE
		
	SEND_BYTE:
		JNB	TI,	$
		CLR	TI
		RET
	
	END	
		
