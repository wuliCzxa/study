	ORG 0
	AJMP START
	ORG 50H

	ORG 003H
	AJMP EXT0_ISR

	ORG 0013H
	AJMP EXT1_ISR

	START:
		MOV P1, #00H
		MOV R0, #00H

		SETB	IT0
		SETB	EX0
		SETB	PX0

		SETB	IT1
		SETB	EX1
		CLR	PX1

		SETB	EA
	
	MAIN_LOOP:
		SJMP	MAIN_LOOP

	EXT0_ISR:
		INC	R0
		MOV	A,	R0
		ANL	A	#7FH
		MOV	P1,	A
		RETI

	EXTI_ISR:
		CLR	P1.7
		RETI
	END


