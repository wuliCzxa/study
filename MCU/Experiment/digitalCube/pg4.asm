	ORG 0
	LJMP MAIN

	ORG 0050H
MAIN:
	MOV R0, #30H     
	MOV R1, #06H     
	MOV R2, #00H     

BCD_TO_7SEG:
	MOV A, @R0       
	MOV B, #10H
	DIV AB           

	MOV DPTR, #TABLE
	MOVC A, @A+DPTR
	MOV R3, A
	MOV R4, R2
	ADD A, #00H     
	MOV 40H[R2], A  
	INC R2           
	MOV A, B
	
	MOV DPTR, #TABLE
	MOVC A, @A+DPTR
	MOV 40H[R2], A
	INC R2

	INC R0           
	DJNZ R1, BCD_TO_7SEG

DISPLAY_LOOP:
	MOV R6, #06H      
	MOV R0, #40H       
	MOV R3, #01H       

DISP_NEXT:
	MOV DPTR, #8001H
	MOV A, R3
	MOVX @DPTR, A      

	MOV A, R3
	RL A
	MOV R3, A         

	MOV A, @R0
	MOV DPTR, #8002H
	MOVX @DPTR, A      

	ACALL DELAY

	INC R0
	DJNZ R6, DISP_NEXT
	LJMP DISPLAY_LOOP

DELAY:
	MOV R5, #02H
DL1:
	MOV R4, #0FFH
	DJNZ R4, $
	DJNZ R5, DL1
	RET

TABLE:
	DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH 

	END

/*
	ORG 0
	LJMP MAIN
	ORG 50H
	MAIN:
		MOV 30H,#12H
		MOV 31H,#34H
		MOV 32H,#56H
	ST:
		MOV R6,#03H 	
		MOV R3,#01H	
		MOV R0,#30H	

	DP:
		MOV DPTR,#8001H	
		MOV A,R3
		MOVX @DPTR,A
		MOV A,R3
		RL A
		MOV R3,A
		MOV A,@R0
		MOV B,#10H
		DIV AB 			
		MOV DPTR,#TABLE				
		MOVC A,@A+DPTR
		MOV DPTR,#8002H
		MOVX @DPTR,A
		ACALL DELAY

		MOV DPTR,#8001H	  
		MOV A,R3
		MOVX @DPTR,A
		MOV A,R3
		RL A
		MOV R3,A
		MOV A,B
		MOV DPTR,#TABLE
		MOVC A,@A+DPTR
		MOV DPTR,#8002H
		MOVX @DPTR,A
		ACALL DELAY

		INC R0
		DJNZ R6,DP
		LJMP ST

	DELAY:
		MOV R5,#01H
		DL:
			MOV R4,#0FFH
			DJNZ R4,$
			DJNZ R5,DL
			RET

	TABLE:
		DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH
		END
*/